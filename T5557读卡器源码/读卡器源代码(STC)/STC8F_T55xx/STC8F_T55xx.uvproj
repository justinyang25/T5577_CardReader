# Keil uVision project STC8F_T55xx.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: STC8F_T55xx +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Header
  group Source Group 1
    ./: STARTUP.A51
  group Scr
    ./Scr/: mian.c Uart.C EM41xx.c CopyEM4100.c EMReadWriteCard.c T5557.c CRC16.c
